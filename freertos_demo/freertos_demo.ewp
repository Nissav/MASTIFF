# IAR project freertos_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM4F120H5QR TexasInstruments LM4F120H5QR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PM; TARGET_IS_BLIZZARD_RB1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..; ..\..\..\..; sourceFiles; ..\..\..\..\third_party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\third_party\FreeRTOS; ..\..\..\..\third_party\FreeRTOS\Source\include; ..\..\..\..\third_party
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: .; ..; ..\..\..\..; ..\..\..\..\third_party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\third_party\FreeRTOS; ..\..\..\..\third_party\FreeRTOS\Source\include; ..\..\..\..\third_party
  OBJCOPY.OOCOutputFile: freertos_demo.bin
  ILINK.IlinkOutputFile: freertos_demo.out
  ILINK.IlinkIcfFile: freertos_demo.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Aux Files
    ../../../../third_party/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../../third_party/FreeRTOS/Source/: list.c queue.c tasks.c
    ../../../../third_party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
    ../drivers/: rgb.c
    ../../../../utils/: uartstdio.c ustdlib.c
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
  group Source
    sourceFiles/: cameraPositioner.c comm.c directionControl.c header.h motorControl.c sensorPositioner.c servoControl.c servoControlPan.c servoControlTilt.c startup.c
    ./: freertos_demo.c startup_ewarm.c
